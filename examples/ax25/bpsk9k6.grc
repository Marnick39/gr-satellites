options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: This example implements a BPSK 9k6 AX.25 transceiver
    generate_options: qt_gui
    id: bpsk9k6
    output_language: python
    title: BPSK 9k6 example
  states: {}

blocks:
- name: bpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-10000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_const
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '5'
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.05'
  states: {}
- name: digital_fll_band_edge_cc_0_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: '0.350'
    samps_per_sym: samp_per_sym
    type: cc
    w: '0.005'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.03'
    max_dev: '0.1'
    nfilters: '16'
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(16, 16, 1/samp_per_sym, 0.35, 11 * samp_per_sym * 16)
    resamp_type: digital.IR_PFB_MF
    sps: samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '200'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '0'
    size: 1200 * 3
    srate: samp_rate
    style1: '0'
    style2: '0'
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_framer_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_kiss_to_pdu_0_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: satellites_pdu_to_kiss_0_0
  id: satellites_pdu_to_kiss
  parameters:
    control_byte: 'True'
    include_timestamp: 'False'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-1'
    reference: '1.0'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [audio_source_0_0, '0', hilbert_fc_0_0, '0']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', digital_constellation_modulator_0, '0']
- [digital_binary_slicer_fb_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_1_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_fll_band_edge_cc_0_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_fll_band_edge_cc_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', satellites_rms_agc_0, '0']
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pdu_pdu_to_tagged_stream_0_0, '0', satellites_kiss_to_pdu_0_0, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', satellites_nrzi_encode_0_0, '0']
- [satellites_hdlc_deframer_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_hdlc_deframer_0_0, out, satellites_pdu_to_kiss_0_0, in]
- [satellites_hdlc_framer_0_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]
- [satellites_kiss_to_pdu_0_0, out, satellites_hdlc_framer_0_0, in]
- [satellites_nrzi_decode_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [satellites_nrzi_encode_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [satellites_pdu_to_kiss_0_0, out, network_socket_pdu_0_0, pdus]
- [satellites_rms_agc_0, '0', digital_fll_band_edge_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
