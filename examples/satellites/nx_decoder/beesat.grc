options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: BEESAT and TECHNOSAT decoder
    generate_options: no_gui
    id: beesat
    output_language: python
    run_options: run
    title: BEESAT and TECHNOSAT decoder
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-invert*10'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: 10*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    gain: '1'
    interp: '1'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv4_addr: 127.0.0.1
    ipv6: 'False'
    notify_missed: 'False'
    port: port
    src_zeros: 'False'
    type: short
  states: {}
- name: note_0
  id: note
  parameters:
    note: 4k8
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_beesat_classifier_0
  id: satellites_beesat_classifier
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '35933'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_submit_0_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '39136'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_submit_0_0_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '41619'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_submit_0_0_0_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42829'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_submit_0_0_0_1
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '99802'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: tnc_nx_nx_decoder_1_0
  id: tnc_nx_nx_decoder
  parameters:
    beesat_mode: 'True'
    framesync: '0x0EF0'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', tnc_nx_nx_decoder_1_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [satellites_beesat_classifier_0, BEESAT-1, satellites_submit_0, in]
- [satellites_beesat_classifier_0, BEESAT-2, satellites_submit_0_0, in]
- [satellites_beesat_classifier_0, BEESAT-4, satellites_submit_0_0_0, in]
- [satellites_beesat_classifier_0, BEESAT-9, satellites_submit_0_0_0_1, in]
- [satellites_beesat_classifier_0, TECHNOSAT, satellites_submit_0_0_0_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_beesat_classifier_0, in]
- [tnc_nx_nx_decoder_1_0, out, satellites_print_timestamp_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
