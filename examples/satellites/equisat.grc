options:
  parameters:
    author: Brown Space Engineering
    description: EQUiSat Decoder
    generate_options: no_gui
    id: equisat
    output_language: python
    run_options: run
    title: EQUiSat Decoder
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.300'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: symbol_depth
  id: variable
  parameters:
    value: '40'
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.2'
    gain: '1.0'
    ntaps: int(symbol_depth*(samp_rate/decimation/4800))
    samp_rate: samp_rate/decimation
    sym_rate: '4800'
  states: {}
- name: api_key
  id: parameter
  parameters:
    label: BSE data server API key
    type: str
    value: ''
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: samp_rate/decimation/4800.0
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: equisat_decoder_equisat_4fsk_block_decode_0
  id: equisat_decoder_equisat_4fsk_block_decode
  parameters:
    msg_size: '255'
    print_packets: 'False'
  states: {}
- name: equisat_decoder_equisat_4fsk_preamble_detect_0
  id: equisat_decoder_equisat_4fsk_preamble_detect
  parameters:
    byte_buf_size: '255'
    max_symbol_ratio: '0.33'
    min_preamble_len: '96'
  states: {}
- name: equisat_decoder_equisat_fec_decoder_0
  id: equisat_decoder_equisat_fec_decoder
  parameters: {}
  states: {}
- name: equisat_decoder_equisat_submitter_0
  id: equisat_decoder_equisat_submitter
  parameters:
    api_key: api_key
    api_route: http://api.brownspace.org/equisat/receive/raw
    latitude: latitude
    longitude: longitude
    post_publicly: bool(post_publicly)
    rec_start: recstart
    source_app: gr-satellites
    station_name: station_name
  states: {}
- name: equisat_decoder_equisat_telemetry_parser_0
  id: equisat_decoder_equisat_telemetry_parser
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: variable_rrc_filter_taps_0
    type: fff
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: your latitude (N is +, S is -, format 00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: your longitude (W is -, E is +, format 00.000)
    type: eng_float
    value: '0'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv4_addr: 127.0.0.1
    ipv6: 'False'
    notify_missed: 'False'
    port: port
    src_zeros: 'False'
    type: short
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: post_publicly
  id: parameter
  parameters:
    label: whether to post any receptions publicly on Twitter using @equisat_bot (set to any value to post)
    type: str
    value: ''
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording in UTC (format YYYY-MM-DD HH:MM:SS); default is realtime
    type: str
    value: ''
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '43552'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: station_name
  id: parameter
  parameters:
    label: station name or callsign
    type: str
    value: ''
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', equisat_decoder_equisat_4fsk_preamble_detect_0, '0']
- [equisat_decoder_equisat_4fsk_block_decode_0, out, equisat_decoder_equisat_fec_decoder_0, in]
- [equisat_decoder_equisat_4fsk_preamble_detect_0, out, equisat_decoder_equisat_4fsk_block_decode_0, in]
- [equisat_decoder_equisat_fec_decoder_0, out, satellites_print_timestamp_0, in]
- [fir_filter_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [satellites_print_timestamp_0, out, equisat_decoder_equisat_submitter_0, in]
- [satellites_print_timestamp_0, out, equisat_decoder_equisat_telemetry_parser_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
