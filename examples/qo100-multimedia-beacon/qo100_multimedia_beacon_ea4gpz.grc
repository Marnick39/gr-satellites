options:
  parameters:
    author: Daniel Estevez
    copyright: 2022 Daniel Estevez <daniel@destevez.net>
    generate_options: qt_gui
    id: qo100_multimedia_beacon_ea4gpz
    output_language: python
    title: QO-100 multimedia beacon RX EA4GPZ
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '25'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: 100//decim1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Tune frequency (Hz)
    type: real
    value: '-110'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: 1392//2
    n: (24+1392)//2
    offset: 24//2
    type: short
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '50100'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 245e3 + tune
    decim: decim1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 3000, samp_rate/decim1 - 2*3000)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: decim2
    gain: '1'
    samp_rate: samp_rate/decim1
    type: fir_filter_ccf
    width: samp_rate/(decim1 * decim2) - 2 * 2500
    win: window.WIN_HAMMING
  states: {}
- name: qo100_multimedia_beacon_0
  id: qo100_multimedia_beacon
  parameters:
    files_path: /tmp/
    samp_rate: '6000'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_udp_source_0, '0', blocks_keep_m_in_n_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qo100_multimedia_beacon_0, '0']

metadata:
  file_format: 1
